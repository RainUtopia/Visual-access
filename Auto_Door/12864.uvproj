# Keil uVision project 12864.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 12864 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 12864.c delay.c DS1302.C main.c menu.c uart.c fifo.c NRF24L01.c OV7670.c sccb.c net_camera.c
